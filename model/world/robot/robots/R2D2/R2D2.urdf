Commit message: URDF update

File: model/world/robot/robots/R2D2/R2D2.urdf (robot description, URDF)
Before this commit: robot R2D2, 14 links, 13 joints
Joints:
- joint gripper_extension: limit lower=-0.38 upper=0 effort=1000.0 velocity=0.5 -> (none)
